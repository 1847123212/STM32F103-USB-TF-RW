# Keil uVision project stm32-tf-rw.uvprojx, settings and files
target stm32f1xx-sd (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: stm32-fd-sd-usb +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD, USE_STM3210E_EVAL
  c include: .\Libraries\CMSIS\Core\CM3;.\Libraries\STM32_USB-FS-Device_Driver\inc;.\Libraries\STM32F10x_StdPeriph_Driver\inc;.\Utilities\STM32_EVAL;.\Utilities\STM32_EVAL\STM3210E_EVAL;.\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group user
    ./src/: stm32f10x_it.c hw_config.c sdio_sdcard.c main.c mass_mal.c memory.c scsi_data.c usb_bot.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c usb_scsi.c
  group USB-FS-Device_Driver
    ./Libraries/STM32_USB-FS-Device_Driver/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group StdPeriph_Driver
    ./Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_usart.c stm32f10x_spi.c stm32f10x_dma.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_sdio.c
  group RVMDK
    ./Libraries/CMSIS/Core/CM3/startup/arm/: startup_stm32f10x_hd.s
  group CMSIS
    ./Libraries/CMSIS/Core/CM3/: core_cm3.c system_stm32f10x.c
software components: CMSIS:CORE 4.3.0
